# Keil uVision project SWM320_StdPeriph_Driver.uvprojx, settings and files
target SWM320 (6160000::V6.16::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.6
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: ..\CSL\CMSIS\CoreSupport;..\CSL\CMSIS\DeviceSupport;..\CSL\SWM320_StdPeriph_Driver;..\APP;..\..\..\Library\Include;..\..\..\Helper\Include;..\..\asset;.\controls;..\..\platform
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../APP/: dev_gt9x.c dev_rgblcd.c dev_systick.c dev_uart.c
    ./: example_gui.c main.c
  group CSL\StdPD
    ../CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_can.c SWM320_crc.c SWM320_dma.c SWM320_exti.c SWM320_flash.c SWM320_gpio.c SWM320_i2c.c SWM320_lcd.c SWM320_norflash.c SWM320_port.c SWM320_pwm.c SWM320_rtc.c SWM320_sdio.c SWM320_sdram.c SWM320_spi.c SWM320_sram.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c
  group CSL\CMSIS
    ../CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group Arm-2D
    ../../../Library/Source/: arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_op_table.c arm_2d_rotation.c arm_2d_tile.c
  group Arm-2D-Helper
    ../../../Helper/Source/: arm_2d_helper_pfb.c
  group platform
    ../../platform/: app_platform.c GLCD_Fonts.c lcd_printf.c
    ../../platform/lib/: perf_counter.lib
  group controls
    ./controls/: busy_wheel.c controls.c
  group asset
    ../../asset/: whilte_dot.c.c arrow.c gear_01.c gear_02.c pointer_sec.c clockface.c watch_panel.c background.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
