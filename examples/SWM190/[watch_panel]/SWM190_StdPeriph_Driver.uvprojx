# Keil uVision project SWM190_StdPeriph_Driver.uvprojx, settings and files
target SWM190 (6160000::V6.16::ARMCLANG)
  device: SWM190xB Synwit
  pack: Synwit.SWM32_DFP.1.16.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SWM190_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: ..\CSL\CMSIS\CoreSupport;..\CSL\CMSIS\DeviceSupport;..\CSL\SWM190_StdPeriph_Driver;..\APP;..\..\..\Library\Include;..\..\..\Helper\Include;..\..\asset;.\controls;..\..\platform
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: dev_spilcd.c dev_systick.c
    ./: example_gui.c main.c
  group CSL\StdPD
    ../CSL/SWM190_StdPeriph_Driver/: SWM190_adc.c SWM190_cache.c SWM190_cordic.c SWM190_div.c SWM190_dma.c SWM190_exti.c SWM190_flash.c SWM190_gpio.c SWM190_i2c.c SWM190_port.c SWM190_pwm.c SWM190_rtc.c SWM190_sleep.c SWM190_spi.c SWM190_timr.c SWM190_uart.c SWM190_wdt.c
  group CSL\CMSIS
    ../CSL/CMSIS/DeviceSupport/: system_SWM190.c
    ../CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM190.s
  group Arm-2D
    ../../../Library/Source/: arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_op_table.c arm_2d_rotation.c arm_2d_tile.c
  group Arm-2D-Helper
    ../../../Helper/Source/: arm_2d_helper_pfb.c
  group platform
    ../../platform/: app_platform.c GLCD_Fonts.c lcd_printf.c
    ../../platform/lib/: perf_counter.lib
  group controls
    ./controls/: controls.c busy_wheel.c
  group asset
    ../../asset/: whilte_dot.c.c gear_01.c gear_02.c pointer_sec.c clockface.c watch_panel.c background.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
